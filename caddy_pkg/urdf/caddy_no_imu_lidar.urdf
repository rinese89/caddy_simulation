Commit message: added IMU y LiDAR

File: caddy_pkg/urdf/caddy_no_imu_lidar.urdf (robot description, URDF)
Before this commit: robot caddy, 9 links, 8 joints
Links:
- removed link base_scan
Joints:
- removed joint scan_joint
